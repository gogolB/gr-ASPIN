<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>USRP_TCP</value></param>
<param><key>author</key><value>Gogol</value></param>
<param><key>description</key><value>Transmit data from the E312 to a target via tcp.</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>USRP_TCP</value></param>
</block>
<block>
<key>ASPIN_Async_TCP_Client</key>
<param><key>id</key><value>ASPIN_Async_TCP_Client_0</value></param>
<param><key>payloadSize</key><value>1472</value></param>
<param><key>port</key><value>25565</value></param>
<param><key>queueSize</key><value>1000000</value></param>
<param><key>serverIP</key><value>192.168.10.10</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>1024</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>1575.42e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>maxoutbuf</key><value>200</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>minoutbuf</key><value>100</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>sc16</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>ASPIN_Async_TCP_Client_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
